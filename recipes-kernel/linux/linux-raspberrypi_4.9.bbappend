# fix  meta-raspberry fetch error 

LINUX_VERSION = "4.9.14"
SRCREV = "59e4f29c63c687fa1387c2a14fd4cf7fddc3df1d"
